# Keil uVision project Template.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F429ZI STMicroelectronics
  cpu: IRAM(0x20000000-0x2002FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: Template
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F429xx,USE_STM32F429I_DISCO
  c include: ..\;..\Config;..\Common;..\..\Package_STM32F4\Drivers\CMSIS\Device;..\..\Package_STM32F4\Drivers\CMSIS\Include;..\..\Package_STM32F4\Drivers\STM32F4xx_HAL_Driver\Inc;..\..\Package_STM32F4\Drivers\BSP\STM32F429I-Discovery;..\..\Package_STM32F4\Middlewares\FreeRTOS\Source\include;..\..\Package_STM32F4\Middlewares\FreeRTOS\Source\portable\RVDS\ARM_CM4F;..\..\Package_STM32F4\Middlewares\FatFs\src;..\..\Package_STM32F4\Middlewares\FatFs\src\drivers;..\..\Package_STM32F4\Middlewares\STM32_USB_Host_Library\Core\Inc;..\..\Package_STM32F4\Middlewares\STM32_USB_Host_Library\Class\MSC\Inc
  asm include: ..\..\Package_STM32F4\Middlewares\FreeRTOS\Source\include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/User
    ../: main.c EPS_NanoPower_P31U.c Environment.c
    ../Config/: stm32f4xx_hal_msp.c stm32f4xx_it.c usbh_conf.c peripheral.c
    ../Common/: common.c
  group Application/MDK-ARM
    ./: startup_stm32f429xx.s
  group Drivers/STM32F4xx_HAL_Driver
    ../../Package_STM32F4/Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_hcd.c stm32f4xx_ll_usb.c
  group Drivers/CMSIS
    ../Config/: system_stm32f4xx.c
  group Middlewares/FreeRTOS/portable
    ../../Package_STM32F4/Middlewares/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../../Package_STM32F4/Middlewares/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Middlewares/FreeRTOS
    ../../Package_STM32F4/Middlewares/FreeRTOS/Source/: list.c queue.c tasks.c timers.c
  group Middlewares/FatFs/Core
    ../../Package_STM32F4/Middlewares/FatFs/src/: ff.c ff_gen_drv.c diskio.c
  group Middlewares/FatFs/Drivers
    ../../Package_STM32F4/Middlewares/FatFs/src/drivers/: usbh_diskio.c
  group Middlewares/STM32_USBH_Library/Class/MSC
    ../../Package_STM32F4/Middlewares/STM32_USB_Host_Library/Class/MSC/Src/: usbh_msc_scsi.c usbh_msc_bot.c usbh_msc.c
  group Middlewares/STM32_USBH_Library/Core
    ../../Package_STM32F4/Middlewares/STM32_USB_Host_Library/Core/Src/: usbh_pipes.c usbh_ioreq.c usbh_ctlreq.c usbh_core.c
